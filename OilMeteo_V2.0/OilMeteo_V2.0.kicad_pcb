# Repository SergejSKoreshkov/Oil-Meteo

## KiCad design OilMeteo_V2.0/OilMeteo_V2.0.kicad_pcb

Parts:
C1, C3, C4, C5, C6, C7, C11, C12, C13, C15, C16, C17, C18: C; C_0805
C2: CP1; CP_Tantalum_Case-C_EIA-6032-28_Reflow
C8, C9, C10, C14: CP1; CP_Tantalum_Case-C_EIA-6032-28_Hand
CH340G1: CH340G; SOP-16_4.4x10.4mm_Pitch1.27mm
D1, D2: D; D_1206
J1: USB_OTG; USB_Micro-B_Wuerth-629105150521
J2: Micro_SD_Card_Det_Hirose_DM3AT; Hirose_DM3AT-SF-PEJM5
J3: Conn_01x03; Pin_Header_Straight_1x03_Pitch2.54mm
J4, J5: Conn_01x03; Pin_Header_Straight_1x03_Pitch1.27mm
J6: Conn_01x06; Pin_Header_Straight_1x06_Pitch2.54mm
PRGRM!1: R; R_0805
PROG1: LED; LED_0805
PWR1: LED; LED_0805
Q1: 2N3904; TO-92_Molded_Narrow
R1, R2, R3, R4, R5, R6, R7, R8, R9, R10, R11, R12, R13, R14, R15, R16, R17, R18, R19, R20, R21, R22, R23, R24, R25, R26, R27, R28: R; R_0805
SD1: LED; LED_0805
SW1: SW_Push; SW_SPST_EVQPE1
U1: ATMEGA328P-AU; TQFP-32_7x7mm_Pitch0.8mm
U2: LM1117-3.3; SOT-223-3_TabPin2
U3: SN74LVC125A; TSSOP-14_4.4x5mm_Pitch0.65mm
U4: LM1117-5.0; SOT-223-3_TabPin2
U5: DS3231; SOIC-16W_7.5x10.3mm_Pitch1.27mm
U6: AT24CS01-SSHM; SOIC-8_3.9x4.9mm_Pitch1.27mm
Y1, Y2: Crystal; Crystal_HC49-U_Vertical

Connections:
+3V3: C14.1, C16.1, J2.4 (VDD), R17.2, U3.14, U4.2 (VO)
+5V: C4.1, C9.1, C13.2, C17.1, CH340G1.16 (Vcc), D1.1 (K), J3.2, J4.1, J5.1, J6.2, PRGRM!1.2, Q1.3 (C), R1.1, R5.2, R6.1, R7.1, R9.1, R11.2, R14.1, R18.2, R19.2, R20.2, R24.1, R25.1, R26.1, R27.1, R28.1, U2.2 (VO), U5.2, U6.8 (VCC)
+5VA: C5.1, D1.2 (A), J1.1 (VBUS)
+12V: J3.1, R15.2
ALARM: R25.2, U1.32 ((PCINT18/INT0)PD2), U5.3
CS: R16.1, R17.1, U1.14 ((PCINT2/OC1B/~SS~)PB2), U3.13
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.1, C7.1, C8.2, C9.2, C10.2, C11.2, C12.2, C14.2, C16.2, C17.2, C18.2, CH340G1.1 (GND), J1.5 (GND), J1.6 (Shield), J2.6 (VSS), J2.11 (SHIELD), J3.3, J4.3, J5.3, J6.6, PROG1.1 (K), PWR1.1 (K), Q1.1 (E), R21.2, R22.2, R23.2, SD1.1 (K), SW1.1, U1.3 (GND), U1.5 (GND), U1.21 (GND), U2.1 (GND), U3.1, U3.4, U3.7, U3.10, U4.1 (GND), U5.5, U5.6, U5.7, U5.8, U5.9, U5.10, U5.11, U5.12, U5.13, U6.4 (GND), U6.7 (WP)
MISO: J6.1, U1.16 ((PCINT4/MISO)PB4), U3.11
MOSI: J6.4, R12.2, U1.15 ((PCINT3/OC2A/MOSI)PB3)
unnamed: C1.1, C2.1, U1.4 (VCC), U1.6 (VCC), U1.18 (AVCC)
unnamed: C3.1, U1.20 (AREF)
unnamed: C6.2, R4.1, U1.7 ((PCINT6/XTAL1/TOSC1)PB6), Y1.1
unnamed: C7.2, R4.2, U1.8 ((PCINT7/XTAL2/TOSC2)PB7), Y1.2
unnamed: C8.1, R15.1, U2.3 (VI)
unnamed: C10.1, PRGRM!1.1, U4.3 (VI)
unnamed: C11.1, CH340G1.7 (XI), Y2.1
unnamed: C12.1, CH340G1.8 (XO), Y2.2
unnamed: C13.1, CH340G1.4 (V3)
unnamed: C15.2, CH340G1.13 (DTR#)
unnamed: C18.1, D2.1 (K), U5.14
unnamed: CH340G1.5 (UD+), J1.3 (D+)
unnamed: CH340G1.6 (UD-), J1.2 (D-)
unnamed: D2.2 (A), R28.2
unnamed: J2.2 (DAT3/CD), U3.8
unnamed: J2.3 (CMD), U3.3
unnamed: J2.5 (CLK), U3.6
unnamed: J2.7 (DAT0), R10.1
unnamed: J2.9 (DET_B), SD1.2 (A)
unnamed: J2.10 (DET_A), R11.1
unnamed: J4.2, U1.23 ((PCINT8/ADC0)PC0)
unnamed: J5.2, R14.2, U1.2 ((PCINT20/XCK/T0)PD4)
unnamed: PROG1.2 (A), R8.1
unnamed: PWR1.2 (A), R5.1
unnamed: Q1.2 (B), R9.2, U1.1 ((PCINT19/OC2B/INT1)PD3)
unnamed: R2.2, U1.30 ((PCINT16/RXD)PD0)
unnamed: R3.2, U1.31 ((PCINT17/TXD)PD1)
unnamed: R8.2, U1.13 ((PCINT1/OC1A)PB1)
unnamed: R10.2, U3.12
unnamed: R12.1, U3.2
unnamed: R13.1, U3.5
unnamed: R16.2, U3.9
unnamed: R18.1, R23.1, U6.3 (A2)
unnamed: R19.1, R22.1, U6.2 (A1)
unnamed: R20.1, R21.1, U6.1 (A0)
unnamed: R24.2, U5.1
RST: C15.1, J6.5, R1.2, SW1.2, U1.29 ((PCINT14/~RESET~)PC6)
RX: CH340G1.2 (TXD), R2.1
SCK: J6.3, R13.2, U1.17 ((PCINT5/SCK)PB5)
SCL: R7.2, R27.2, U1.28 ((PCINT13/SCL/ADC5)PC5), U5.16, U6.6 (SCL)
SDA: R6.2, R26.2, U1.27 ((PCINT12/SDA/ADC4)PC4), U5.15, U6.5 (SDA)
TX: CH340G1.3 (RXD), R3.1

Board: 2 copper layers, 95.0 x 18.0 mm, 69 parts (24 on the bottom side), 51 nets.

## KiCad design Oil_Meteo2/Oil_Meteo/Oil_Meteo.kicad_pcb

Parts:
0.1uF1: CP1; CP_Tantalum_Case-A_EIA-3216-18_Reflow
0.1uF2, 0.1uF3, 4.7uF1, 22uF1, 22uF2, 100n1, 100nF1, 104.1: C; C_0805
1M1: R; R_0805
1uF1: C; C_0805_HandSoldering
4.7uF2, 10uF1: CP1; CP_Tantalum_Case-B_EIA-3528-21_Reflow
12MHz1, 16MHz1: Crystal; Crystal_HC49-4H_Vertical
C2: C; C_0805
CH340G1: CH340G; SOP-16_4.4x10.4mm_Pitch1.27mm
CTal1, CTal2: C; C_0805
HEF40501: HEF4050; TSSOP-16-1EP_4.4x5mm_Pitch0.65mm
ICSP1: CONN_01X06; Pin_Header_Straight_1x06_Pitch2.54mm
J1: Micro_SD_Card; microSD_Card_Receptacle_Wuerth_693072010801
J2: USB_OTG; USB_Mini-B
J3: CONN_01X03; Pin_Header_Straight_1x03_Pitch2.00mm
J4: CONN_01X03; Pin_Header_Straight_1x03_Pitch2.54mm
MBR520: D_Schottky_ALT; D_1206
Power1: LED; LED_0805
Press1: CONN_01X03; Pin_Header_Straight_1x03_Pitch2.00mm
Q1: 2N3904; TO-92_Molded_Narrow
R1: R; R_0805
RRX1: R; R_0805
RTX1: R; R_0805
Restart1: SW_Push; SW_SPST_EVQPE1
U1: ATMEGA328P-AU; TQFP-32_7x7mm_Pitch0.8mm
U2: LM1117-5.0; SOT-223-3_TabPin2
forSD1: LM1117-3.3; SOT-223-3_TabPin2

Connections:
+3V3: 100n1.1, 104.1.1, HEF40501.1 (Vdd), J1.4 (VDD), forSD1.2 (VO)
+5V: 0.1uF1.1, 1M1.2, 1uF1.1, 4.7uF1.1, 10uF1.1, 100nF1.2, CH340G1.16 (Vcc), ICSP1.2, J3.1, J4.2, MBR520.1 (K), Press1.1, Q1.3 (C), R1.2, U1.4 (VCC), U1.6 (VCC), U1.18 (AVCC), U2.2 (VO), forSD1.3 (VI)
+5VD: 0.1uF3.1, 4.7uF2.1, J2.1 (VBUS), MBR520.2 (A)
+12V: J4.3, U2.3 (VI)
GND: 0.1uF1.2, 0.1uF2.2, 0.1uF3.2, 1uF1.2, 4.7uF1.2, 4.7uF2.2, 10uF1.2, 22uF1.2, 22uF2.1, 100n1.2, 104.1.2, CH340G1.1 (GND), CTal1.1, CTal2.1, HEF40501.8 (Vss), ICSP1.6, J1.3 (CMD), J1.6 (VSS), J1.9 (SHIELD), J2.5 (GND), J2.6 (Shield), J3.3, J4.1, Power1.1 (K), Press1.3, Q1.1 (E), Restart1.2, U1.3 (GND), U1.5 (GND), U1.21 (GND), U2.1 (GND), forSD1.1 (GND)
unnamed: 0.1uF2.1, U1.20 (AREF)
unnamed: 1M1.1, Power1.2 (A)
unnamed: 12MHz1.1, 22uF1.1, CH340G1.7 (XI)
unnamed: 12MHz1.2, 22uF2.2, CH340G1.8 (XO)
unnamed: 16MHz1.1, CTal1.2, U1.7 ((PCINT6/XTAL1/TOSC1)PB6)
unnamed: 16MHz1.2, CTal2.2, U1.8 ((PCINT7/XTAL2/TOSC2)PB7)
unnamed: 100nF1.1, CH340G1.4 (V3)
unnamed: C2.1, ICSP1.5, R1.1, Restart1.1, U1.29 ((PCINT14/~RESET~)PC6)
unnamed: C2.2, CH340G1.13 (DTR#)
unnamed: CH340G1.2 (TXD), RRX1.1
unnamed: CH340G1.3 (RXD), RTX1.1
unnamed: CH340G1.5 (UD+), J2.3 (D+)
unnamed: CH340G1.6 (UD-), J2.2 (D-)
unnamed: HEF40501.9 (4A), U1.9 ((PCINT21/OC0B/T1)PD5)
unnamed: HEF40501.10 (4Y), J1.1 (DAT2)
unnamed: HEF40501.11 (5A), ICSP1.4, U1.15 ((PCINT3/OC2A/MOSI)PB3)
unnamed: HEF40501.12 (5Y), J1.2 (DAT3/CD)
unnamed: HEF40501.14 (6A), ICSP1.3, U1.17 ((PCINT5/SCK)PB5)
unnamed: HEF40501.15 (6Y), J1.5 (CLK)
unnamed: ICSP1.1, J1.7 (DAT0), U1.16 ((PCINT4/MISO)PB4)
unnamed: J3.2, U1.2 ((PCINT20/XCK/T0)PD4)
unnamed: Press1.2, U1.23 ((PCINT8/ADC0)PC0)
unnamed: Q1.2 (B), U1.1 ((PCINT19/OC2B/INT1)PD3)
unnamed: RRX1.2, U1.30 ((PCINT16/RXD)PD0)
unnamed: RTX1.2, U1.31 ((PCINT17/TXD)PD1)

Board: 2 copper layers, 95.0 x 18.0 mm, 36 parts (17 on the bottom side), 30 nets.

## Commit log

2018-01-23 1
    1
2018-01-23 Delete
2018-01-30 KiCa files
2018-01-30 kicad
